# Keil uVision project Day15.uvprojx, settings and files
target Day15 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Day15
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\app;.\bsp;.\Drivers;.\interface
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./app/: app_main.c app_servo_ctrl.c main.c
  group Interface
    ./interface/: adc_if.c servo_if.c time_if.c uart_if.c
  group BSP
    ./bsp/: bsp_adc.c bsp_servo.c bsp_time.c bsp_uart.c
  group Drivers
    ./Drivers/: drv_adc1_dma.c drv_systick.c drv_tim4_pwm.c drv_usart1.c tim_drv.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
